PRGSEG  SEGMENT CODE
RSEG    PRGSEG

PUBLIC LICZ

LICZ:
MOV R1,#0
LOOP:
MOV DPTR,#8009H
MOVX @DPTR,A
INC A
MOV R1,A

MOV DPTR,#-65025
WAIT_LOOP:
NOP
NOP
NOP
NOP
NOP
NOP
NOP
NOP
INC DPTR
MOV A,DPH
ORL A,DPL
JNZ WAIT_LOOP
MOV A,R1
SJMP LOOP
    
RET
END
