# Keil uVision project mkd51sim.uvproj, settings and files
target Symulator MKD51 (MCS-51)
  device: 87C51 Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: mkd51sim
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Wait_10uS.a51 liczASM.a51 lcd.c
target MKD51 (MCS-51)
  device: 87C51 Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: mkd51sim +hex
  c flags: Optimize=8 SizeSpeed=1
